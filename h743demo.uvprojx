# Keil uVision project h743demo.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: h743demo +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: .\App;.\Flash;.\LAN8720A
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Listings\h743demo.sct
  group App
    ./App/: app_main.c demo_sd_flashfs.c
  group Config
    ./Config/: stdout_USART.c stdout_user.c USBD_User_CDC_ACM_RNDIS_VETH_0.c
  group :STM32CubeMX:Common Sources
    ./STM32CubeMX/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./STM32CubeMX/STCubeGenerated/Inc/: stm32h7xx_it.h
  group Flash
    ./Flash/: W25Q64J.c
  group ETH Phy
    ./LAN8720A/: PHY_LAN8720A.c EMAC_CDC_ACM_RNDIS.c
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, CMSIS Driver:Ethernet PHY:Custom 1.0.0, CMSIS Driver:Ethernet:Custom 1.0.0, CMSIS Driver:Flash:Custom 1.0.0, CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDOUT:Custom 1.0.0, CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:RTOS2:FreeRTOS 10.5.1, File System:CORE 6.16.6, File System:Drive:Memory Card 6.16.6, File System:Drive:NOR 6.16.6, Network:CORE 7.19.0, Network:Interface:ETH 7.19.0, Network:Service:Web Server Compact 7.19.0, Network:Socket:BSD 7.19.0, Network:Socket:TCP 7.19.0, Network:Socket:UDP 7.19.0, USB:CORE 6.17.0, USB:Device 6.17.0, USB:Device:CDC 6.17.0, CMSIS Driver:Ethernet MAC 1.6.0, CMSIS Driver:MCI 1.8.0, CMSIS Driver:SPI 1.6.0, CMSIS Driver:USART 2.3.0, CMSIS Driver:USB Device 1.6.0, CMSIS Driver:USB Host 1.3.0, CMSIS-Compiler:File Interface:MDK-MW File System 1.0.0, Device:STM32Cube HAL:Common 1.11.0, Device:STM32Cube HAL:Cortex 1.11.0, Device:STM32Cube HAL:DMA 1.11.0, Device:STM32Cube HAL:ETH 1.11.0, Device:STM32Cube HAL:FDCAN 1.11.0, Device:STM32Cube HAL:GPIO 1.11.0, Device:STM32Cube HAL:IRDA 1.11.0, Device:STM32Cube HAL:MMC 1.11.0, Device:STM32Cube HAL:PCD 1.11.0, Device:STM32Cube HAL:PWR 1.11.0, Device:STM32Cube HAL:RCC 1.11.0, Device:STM32Cube HAL:RNG 1.11.0, Device:STM32Cube HAL:RTC 1.11.0, Device:STM32Cube HAL:SD 1.11.0, Device:STM32Cube HAL:SPI 1.11.0, Device:STM32Cube HAL:Smartcard 1.11.0, Device:STM32Cube HAL:TIM 1.11.0, Device:STM32Cube HAL:UART 1.11.0, Device:STM32Cube HAL:USART 1.11.0, Device:Startup 1.11.0
